# Keil uVision project TM4C_FreeRTOS.uvprojx, settings and files
target Default_Project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Default_Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c include: D:\TI\TivaWare_C_Series-2.1.2.111;.\Source\include;.\FreeRTOS\include;.\FreeRTOS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    F:/Microcontroller_Projects/IMU_10DOF/Startup/: startup_rvmdk.S
  group Source
    ./Source/: main.c PLL.c GPIO.c UART.c led_task.c switch_task.c
    ./Source/drivers/: buttons.c rgb.c
  group Library
    D:/TI/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
  group FreeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c
    ./FreeRTOS/MemMang/: heap_2.c
    ./FreeRTOS/ARM_CM4F/: port.c
